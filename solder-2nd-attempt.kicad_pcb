# Repository aquaseals/solder-monkey

File README.md:

# solder-monkey
A little personalized monkey buddy that turns evil in the dark! My first PCB for the solder YSWS

## Schematic

## 3D View

## PCB

## Features
- photoresistor to control when LEDs will be on (dark) and off (light)
- capacitor for a cool light fade effect on the LEDs
- toggle button switch to turn off LEDs even when dark outside

## Bill of Materials
- 1 Battery Holder
- 1 2.2M Resistor
- 1 47k Resistor
- 1 4.7k Resistor
- 1 Potentiometer
- 1 47k Resistor
- 2 470 Resistors
- 2 LEDs
- 1 470nF Capacitor
- 1 10uF Capacitor
- 1 Photoresistor
- 1 100k Resistor
- 1 220 Resistor
- 3 NPN Transistors
- 1 Push Button

Made by @haya on slack!

## KiCad design solder-2nd-attempt.kicad_pcb

Board: 2 copper layers, 99.1 x 96.5 mm, 18 parts (7 on the bottom side), 10 nets.

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3034_1x20mm
C1, C2: C; CP_Radial_D8.0mm_P5.00mm
D1, D2: LED; LED_D5.0mm
Q1, Q2, Q3: NPN; TO-92L_HandSolder
R1, R2, R4, R5, R6, R7, R8: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: R_Photo; R_LDR_5.1x4.3mm_P3.4mm_Vertical
RV1: R_Potentiometer; Potentiometer_Vishay_T73YP_Vertical
SW1: SW_Push; SW_PUSH_6mm

Connections:
GND: BT1.2 (-), C1.2, C2.2, D1.1 (K), D2.1 (K), Q2.3 (E), Q3.3 (E), R3.2, R8.2
unnamed: BT1.1 (+), R4.1, R5.1
unnamed: C2.1, R7.2, SW1.1
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R1.2
unnamed: C1.1, Q1.1 (C), Q1.2 (B), R3.1, RV1.1
unnamed: Q1.3 (E), R1.1, R2.1
unnamed: Q2.2 (B), Q3.1 (C), R5.2, R7.1
unnamed: Q2.1 (C), R4.2, R6.2, RV1.2
unnamed: Q3.2 (B), R6.1, R8.1, SW1.2

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BT1,BatteryHolder_Keystone_3034_1x20mm,1,Battery_Cell,
"C1, C2",CP_Radial_D8.0mm_P5.00mm,2,C,
"D1, D2",LED_D5.0mm,2,LED,
"Q1, Q2, Q3",TO-92L_HandSolder,3,NPN,
"R1, R2, R4, R5, R6, R7, R8",R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,7,R,
R3,R_LDR_5.1x4.3mm_P3.4mm_Vertical,1,R_Photo,
RV1,Potentiometer_Vishay_T73YP_Vertical,1,R_Potentiometer,
SW1,SW_PUSH_6mm,1,SW_Push,

## Commit log

2025-06-06 updated schematic + pcb
